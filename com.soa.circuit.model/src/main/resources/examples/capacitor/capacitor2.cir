v v1 1 0 5.0 ac SINE 40.0
#v v1 1 0 5.0 dc
r r1 1 2 100.0
d d1 2 0 0.1
c c1 2 3 10mi
r r2 3 0 5000.0
