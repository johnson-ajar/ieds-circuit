#RLC-Series
v v1 1 0 5.0 ac SINE 41.1
r r1 1 2 10.0
c c1 2 3 15mi
l l1 3 0 1.0
